Commit message: changed gains in DemoController, end of marker URDF

File: src/puma/puma.urdf (robot description, URDF)
Before this commit: robot puma, 7 links, 6 joints
Links:
- link end-effector: mass 0.09 -> 0.01; geometry visual mesh filename=puma_graphics/shaft2_bl.obj scale=0.5 0.115 0.5
